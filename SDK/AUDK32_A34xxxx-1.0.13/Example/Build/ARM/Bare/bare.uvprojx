# Keil uVision project bare.uvprojx, settings and files
target A34M41x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A34M41x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: ..\..\..\..\Framework\CMSIS\Core\Include;..\..\..\..\Framework\CMSIS\Device\ABOV\Include;..\..\..\..\ProductConfig\Config;..\..\..\..\Platform\HAL\Include;..\..\..\..\Platform\HAL\HPL\Include;..\..\..\..\Platform\Library\ABOV\Debug\Include;..\..\..\..\Example\Source\Bare\Peripheral\Include
  asm include: ..\..\..\..\Framework\CMSIS\Core\Include;..\..\..\..\Framework\CMSIS\Device\ABOV\Include;..\..\..\..\ProductConfig\Config;..\..\..\..\Platform\HAL\Include;..\..\..\..\Platform\HAL\HPL\Include;..\..\..\..\Platform\Library\ABOV\Debug\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a34xxxx.sct
  link misc: --diag_suppress L6314W
  group Config
    ../../../../ProductConfig/Config/: abov_config.h abov_example_config.h
  group Main
    ../../../Source/Bare/Peripheral/Main/: ex_peripheral.c ex_common.c
  group Example
    ../../../Source/Bare/Peripheral/SCU/: scu.c scu_clk.c scu_lvd.c scu_pwr.c
    ../../../Source/Bare/Peripheral/PCU/: pcu.c
    ../../../Source/Bare/Peripheral/Timer1/: timer1.c
    ../../../Source/Bare/Peripheral/I2C/: i2c.c
    ../../../Source/Bare/Peripheral/SPI/: spi.c
    ../../../Source/Bare/Peripheral/WDT/: wdt.c
    ../../../Source/Bare/Peripheral/UART/: uart.c
    ../../../Source/Bare/Peripheral/ADC/: adc.c
    ../../../Source/Bare/Peripheral/Flash/: flash.c
    ../../../Source/Bare/Peripheral/CRC/: crc.c
    ../../../Source/Bare/Peripheral/FRT/: frt.c
    ../../../Source/Bare/Peripheral/RNG/: rng.c
    ../../../Source/Bare/Peripheral/AES/: aes.c
    ../../../Source/Bare/Peripheral/MPWM/: mpwm.c
    ../../../Source/Bare/Peripheral/QEI/: qei.c
    ../../../Source/Bare/Peripheral/CMP/: cmp.c
    ../../../Source/Bare/Peripheral/PGA/: pga.c
    ../../../Source/Bare/Peripheral/LPUART/: lpuart.c
    ../../../Source/Bare/Peripheral/USART/: usart.c
    ../../../Source/Bare/Peripheral/DAC/: dac.c
    ../../../Source/Bare/Peripheral/RTC/: rtc.c
    ../../../Source/Bare/Peripheral/LCD/: lcd.c
    ../../../Source/Bare/Peripheral/VREFBUF/: vrefbuf.c
    ../../../Source/Bare/Peripheral/PWM/: pwm.c
  group Startup
    ../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a34xxxx.c
  group System
    ../../../../Framework/CMSIS/Device/ABOV/Source/: system_a34xxxx.c
  group HAL
    ../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c hal_scu_lvd.c hal_scu_pwr.c
    ../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../Platform/HAL/FRT/: hal_frt.c
    ../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
    ../../../../Platform/HAL/RNG/: hal_rng.c
    ../../../../Platform/HAL/AES/: hal_aes.c
    ../../../../Platform/HAL/MPWM/: hal_mpwm.c
    ../../../../Platform/HAL/QEI/: hal_qei.c
    ../../../../Platform/HAL/CMP/: hal_cmp.c
    ../../../../Platform/HAL/PGA/: hal_pga.c
    ../../../../Platform/HAL/LPUART/: hal_lpuart.c
    ../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../Platform/HAL/DAC/: hal_dac.c
    ../../../../Platform/HAL/RTC/: hal_rtc.c
    ../../../../Platform/HAL/LCD/: hal_lcd.c
    ../../../../Platform/HAL/VREFBUF/: hal_vrefbuf.c
    ../../../../Platform/HAL/QSPI/: hal_qspi.c
    ../../../../Platform/HAL/PWM/: hal_pwm.c
  group Debug
    ../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group Linker_AC5
    ../../../../Framework/CMSIS/Device/ABOV/Source/ARM/: ac5_a34xxxx.sct
  group Linker_AC6
    ../../../../Framework/CMSIS/Device/ABOV/Source/ARM/: ac6_a34xxxx.sct
target A34M42x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A34M42x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a34m42x.sct
  link misc: --diag_suppress L6314W
target A34L71x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A34L71x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a34l71x.sct
  link misc: --diag_suppress L6314W
target A34G43x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A34G43x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a34g43x.sct
  link misc: --diag_suppress L6314W
