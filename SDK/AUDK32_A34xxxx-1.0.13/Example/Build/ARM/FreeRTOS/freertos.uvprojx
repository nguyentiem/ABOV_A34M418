# Keil uVision project freertos.uvprojx, settings and files
target A34G43x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: freertos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EXTRN_SUBFAMILY_A34G43x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: ..\..\..\..\Framework\CMSIS\Core\Include;..\..\..\..\Framework\CMSIS\Device\ABOV\Include;..\..\..\..\ProductConfig\Config;..\..\..\..\Platform\HAL\Include;..\..\..\..\Platform\HAL\HPL\Include;..\..\..\..\Platform\Library\ABOV\Debug\Include;..\..\..\..\Platform\OS\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\..\..\Platform\OS\FreeRTOS\include;..\..\..\..\Platform\Library\ABOV\vKernel\FreeRTOS\CMSIS_RTOS_V1;..\..\..\..\Platform\Library\ABOV\vKernel\FreeRTOS\CMSIS_RTOS_V2;..\..\..\..\Example\Source\FreeRTOS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a34g43x.sct
  link misc: --diag_suppress L6314W
  group Config
    ../../../../ProductConfig/Config/: abov_config.h abov_example_config.h
  group Startup
    ../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a34xxxx.c
  group System
    ../../../../Framework/CMSIS/Device/ABOV/Source/: system_a34xxxx.c
  group HAL
    ../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c
    ../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Debug
    ../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group FreeRTOS
    ../../../../Platform/OS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Platform/OS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../../../Platform/OS/FreeRTOS/portable/MemMang/: heap_4.c
  group vKernel
    ../../../../Platform/Library/ABOV/vKernel/FreeRTOS/CMSIS_RTOS_V1/: cmsis_os.c
    ../../../../Platform/Library/ABOV/vKernel/FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
  group Main
    ../../../Source/FreeRTOS/include/: freertos_example.h
    ../../../Source/FreeRTOS/: freertos_main.c freertos_native.c cmsis_rtos_v1.c cmsis_rtos_v2.c
