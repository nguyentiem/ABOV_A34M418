# IAR project freertos.ewp, settings and files
configuration A34G43x (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A34G43x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.CCIncludePath2: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Platform\OS\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\..\..\..\Platform\OS\FreeRTOS\include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Platform\Library\ABOV\vKernel\FreeRTOS\CMSIS_RTOS_V1; ..\..\..\..\..\Platform\Library\ABOV\vKernel\FreeRTOS\CMSIS_RTOS_V2; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include; ..\..\..\..\..\Example\Source\FreeRTOS\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Platform\OS\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\..\..\..\Platform\OS\FreeRTOS\include; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include; ..\..\..\..\..\Example\Source\FreeRTOS\include
  OBJCOPY.OOCOutputFile: freertos.srec
  ILINK.IlinkOutputFile: freertos.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a34g43x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Config
    ../../../../../ProductConfig/Config/: abov_config.h abov_example_config.h
  group Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group FreeRTOS
    ../../../../../Platform/OS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/MemMang
    ../../../../../Platform/OS/FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/portable
    ../../../../../Platform/OS/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group HAL
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Main
    ../../../../Source/FreeRTOS/: cmsis_rtos_v1.c cmsis_rtos_v2.c freertos_main.c freertos_native.c
    ../../../../Source/FreeRTOS/include/: freertos_example.h
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a34xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a34xxxx.c
  group vKernel
    ../../../../../Platform/Library/ABOV/vKernel/FreeRTOS/CMSIS_RTOS_V1/: cmsis_os.c
    ../../../../../Platform/Library/ABOV/vKernel/FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
