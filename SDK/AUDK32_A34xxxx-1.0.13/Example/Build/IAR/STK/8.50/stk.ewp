# IAR project stk.ewp, settings and files
configuration A34M41x (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A34M41x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.CCIncludePath2: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stk.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a34xxxx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration A34M42x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A34M42x; EXTRN_ABOV_EXAMPLE_CONFIG
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a34m42x.icf
configuration A34L71x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A34L71x; EXTRN_ABOV_EXAMPLE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a34l71x.icf
configuration A34G43x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A34G43x; EXTRN_ABOV_EXAMPLE_CONFIG
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a34g43x.icf
  group Config
    ../../../../../ProductConfig/Config/: abov_config.h abov_example_config.h
  group Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group HAL
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Main
    ../../../../Source/GpioLedBlinking/: gpio_led_blinking.c
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a34xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a34xxxx.c
