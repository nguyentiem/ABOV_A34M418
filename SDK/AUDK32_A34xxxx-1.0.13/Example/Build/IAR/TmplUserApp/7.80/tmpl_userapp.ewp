# IAR project tmpl_userapp.ewp, settings and files
configuration A34M41x (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A34M41x; EXTRN_ABOV_MODULE_CONFIG
  ICCARM.CCIncludePath2: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tmpl_userapp.srec
  ILINK.IlinkOutputFile: tmpl_userapp.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a34xxxx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration A34M42x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A34M42x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a34m42x.icf
configuration A34L71x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A34L71x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a34l71x.icf
configuration A34G43x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A34G43x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a34g43x.icf
  group Config
    ../../../../../ProductConfig/Config/: abov_config.h abov_module_config.h
  group Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group HAL
    ../../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../../Platform/HAL/AES/: hal_aes.c
    ../../../../../Platform/HAL/CMP/: hal_cmp.c
    ../../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../../Platform/HAL/DAC/: hal_dac.c
    ../../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../../Platform/HAL/FRT/: hal_frt.c
    ../../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../../Platform/HAL/LCD/: hal_lcd.c
    ../../../../../Platform/HAL/LPUART/: hal_lpuart.c
    ../../../../../Platform/HAL/MPWM/: hal_mpwm.c
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/PGA/: hal_pga.c
    ../../../../../Platform/HAL/PWM/: hal_pwm.c
    ../../../../../Platform/HAL/QEI/: hal_qei.c
    ../../../../../Platform/HAL/QSPI/: hal_qspi.c
    ../../../../../Platform/HAL/RNG/: hal_rng.c
    ../../../../../Platform/HAL/RTC/: hal_rtc.c
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c hal_scu_lvd.c hal_scu_pwr.c
    ../../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../../Platform/HAL/VREFBUF/: hal_vrefbuf.c
    ../../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Main
    ../../../../Source/TmplUserApp/: main.c prv_scu_clk.c prv_user_code.c
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a34xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a34xxxx.c
