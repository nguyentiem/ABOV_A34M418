# Keil uVision project app.uvprojx, settings and files
target A34M41X (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_DEBUG=1 CONFIG_DEBUG_SERIAL_FIFO=1
  c include: ..\..\a34m41x;..\..\..\..\..\core\cmsis\include;..\..\..\..\..\core\device\a34m41x\include;..\..\..\..\..\driver\a34m41x\include;..\..\..\..\..\library\debug\include;..\..\..\..\..\library\tinycrypt\lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ../../: main.c
    ../../../../../library/tinycrypt/lib/source/: utils.c aes_decrypt.c aes_encrypt.c
    ../: a34m41x_system_setting.c a34m41x_debug.c a34m41x_port_init.c
  group core
    ../../../../../core/device/a34m41x/source/: a34m41x_system.c a34m41x_startup_arm.s
  group driver
    ../../../../../driver/a34m41x/source/: a34m41x_aes128.c a34m41x_dma.c a34m41x_gpio.c a34m41x_scu.c a34m41x_timer.c a34m41x_uart.c
  group library
    ../../../../../library/debug/source/: debug_retarget.c debug_serial.c debug_log.c debug_cmd.c debug_hardfault.c
