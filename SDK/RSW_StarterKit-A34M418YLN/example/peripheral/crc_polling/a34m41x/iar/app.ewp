# IAR project app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A34M418 ABOV A34M418
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CONFIG_DEBUG=1; CONFIG_DEBUG_SERIAL_FIFO=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\driver\a34m41x\include; ..\..\..\..\..\core\cmsis\include; ..\..\..\..\..\core\device\a34m41x\include; ..; ..\..\..\..\..\library\debug\include; ..\..\..\..\..\library\crc\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.hex
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ABOV\a34m418.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group A34M41X/app
    ../: a34m41x_debug.c a34m41x_port_init.c a34m41x_system_setting.c
    ../../: main.c
  group A34M41X/core
    ../../../../../core/device/a34m41x/source/: a34m41x_startup_iar.s a34m41x_system.c
  group A34M41X/driver
    ../../../../../driver/a34m41x/source/: a34m41x_crc.c a34m41x_dma.c a34m41x_gpio.c a34m41x_scu.c a34m41x_uart.c
  group A34M41X/library
    ../../../../../library/crc/source/: crc16_sw.c crc32_sw.c crc7_sw.c crc8_sw.c
    ../../../../../library/debug/source/: debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
